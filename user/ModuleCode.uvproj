# Keil uVision project ModuleCode.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ModuleCode +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\driver
  group driver
    ./: STARTUP.A51
    ../driver/: seg.c seg.h key.c key.h led.c led.h onewire.c onewire.h ds1302.c ds1302.h ultrasound.c ultrasound.h iic.c iic.h uart.c uart.h
  group user
    ./: main.c
